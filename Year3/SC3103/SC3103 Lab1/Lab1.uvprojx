# Keil uVision project Lab1.uvprojx, settings and files
target HelloWorld (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\LibraryFiles\FreeRTOS_CORE\include;.\LibraryFiles\Hardware;.\LibraryFiles\STM32F4xx_Driver\inc;.\LibraryFiles\SYSTEM\delay;.\LibraryFiles\SYSTEM\sys;.\LibraryFiles\CORE;.\LibraryFiles\FreeRTOS_PORTABLE;.\LibraryFiles\Hardware;.\LibraryFiles\STM32F4xx_Driver\inc;..\SC3103 Lab1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group CORE
    ./LibraryFiles/CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group SYSTEM
    ./LibraryFiles/SYSTEM/delay/: delay.c
    ./LibraryFiles/SYSTEM/sys/: sys.c system.c
  group HARDWARE
    ./LibraryFiles/Hardware/: led.c oled.c show.c
    ./: buzz.h buzz.c
  group FREERTOS
    ./LibraryFiles/FreeRTOS_PORTABLE/: heap_4.c port.c
    ./LibraryFiles/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group STM32F4xx_Driver
    ./LibraryFiles/STM32F4xx_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
